# Keil uVision project blinky.uvproj, settings and files
target blinky1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: blinky
  c flags: Optim=1
  c include: .\src\bsp
  asm misc: --predefine "REMAP SETL {TRUE}"  --predefine "RAM_MODE SETL {TRUE}"
  memory RVCT4: ROM 0x40000000 size 0x3fff
  memory RVCT9: RAM 0x40004000 size 0x3fff
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --entry 0x40000000
  group Startup Code
    ./src/: LPC2300.s
  group System Calls
    ./src/: Retarget.c
  group Source Code
    ./src/: blinky1.c statetbl.c
  group BSP
    ./src/bsp/: adc.c bspblinky.c timer.c LCD_4bit.c Serial.c led.c
