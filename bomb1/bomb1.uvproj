# Keil uVision project bomb1.uvproj, settings and files
target bomb1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: bomb1
  c flags: Optim=1
  c define: BOMB BSP_KEYBOARD
  c include: ..\bombqmbsp;..\..\..\..\..\..\..\CPU_Platforms\ARM\ARM7\MCB2300\include;..\..\..\..\..\..\..\Framewworks\Quantum\qpc_5.3.1\qpc\ports\arm7\Keil;..\..\..\..\..\..\..\Framewworks\Quantum\qpc_5.3.1\qpc\include
  asm misc: --predefine "REMAP SETL {TRUE}"  --predefine "RAM_MODE SETL {TRUE}"
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x3fff
  memory RVCT9: RAM 0x40004000 size 0x3fff
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --entry 0x40000000
  group startup
    ../../../../../../../CPU_Platforms/ARM/ARM7/MCB2300/startup/: startup.s swi_interrup.s
    ../../../../../../../CPU_Platforms/ARM/ARM7/MCB2300/retarget/: Retarget.c
  group drivers
    ../../../../../../../CPU_Platforms/ARM/ARM7/MCB2300/drivers/: Serial.c QEP_timer.c LCD_4bit.c
  group app
    ./src/: bomb1.c
  group bombqmbsp
    ../bombqmbsp/: bombqmbsp.c
